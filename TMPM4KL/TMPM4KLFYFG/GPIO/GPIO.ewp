# IAR project GPIO.ewp, settings and files
configuration Debug iRAM (ARM, debug)
  General.OGChipSelectEditMenu: TMPM4KLFYFG Toshiba TMPM4KLFYFG
  General.RTConfigPath2: $TOOLKIT_DIR$/inc/c/DLib_Config_Normal.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCDefines: TMPM4KL
  ICCARM.CCIncludePath2: ..\..\Libraries\CMSIS; $TOOLKIT_DIR$\inc\Toshiba
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: GPIO.hex
  ILINK.IlinkOutputFile: GPIO.out
  ILINK.IlinkIcfFile: TMPM4KLFYFG_RAM.icf
  ILINK.IlinkProgramEntryLabel: Reset_Handler
configuration Debug iFlash (ARM, debug)
  as the first configuration, except:
  ILINK.IlinkIcfFile: TMPM4KLFYFG_Flash.icf
  group (top)
    ./: main.c readme.txt
    ../../Libraries/CMSIS/startup/iar/: startup_TMPM4KL.s
    ../../Libraries/CMSIS/: system_TMPM4Ky.c
