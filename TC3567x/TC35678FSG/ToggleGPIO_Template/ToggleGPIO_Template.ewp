# IAR project ToggleGPIO_Template.ewp, settings and files
configuration Release (ARM)
  General.OGChipSelectEditMenu: TC35678FSG Toshiba TC35678FSG
  General.RTConfigPath2: $TOOLKIT_DIR$/INC/c/DLib_Config_Normal.h
  General.CoreVariant: 34
  General.FPU2: 0
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: ToggleGPIO_Template.hex
  ILINK.IlinkOutputFile: toggleGPIO.out
  ILINK.IlinkProgramEntryLabel: C2_Task
  group (top)
    src/: c2_task.c
