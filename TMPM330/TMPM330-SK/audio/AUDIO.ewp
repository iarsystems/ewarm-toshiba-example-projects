# IAR project AUDIO.ewp, settings and files
configuration RAM (ARM, debug)
  General.OGChipSelectEditMenu: TMPM330FDFG Toshiba TMPM330FDFG
  General.RTConfigPath2: $TOOLKIT_DIR$/inc/c/DLib_Config_Normal.h
  General.CoreVariant: 38
  General.FPU2: 0
  ICCARM.CCIncludePath2: App\inc; Fwlib\inc
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: DEMO_AUDIO.srec
  ILINK.IlinkOutputFile: DEMO_AUDIO.out
  ILINK.IlinkIcfFile: TMPM330_RAM.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration FLASH (ARM, debug)
  as the first configuration, except:
  ILINK.IlinkIcfFile: TMPM330_Flash.icf
  group App
    App/src/: adc.c hw_config.c i2c.c lcd.c main.c system_it.c timer.c uart.c
  group FWLib
    Fwlib/src/: m330_adc.c m330_cec.c m330_cg.c m330_flash.c m330_int.c m330_lib.c m330_port.c m330_rmc.c m330_rtc.c m330_sbi.c m330_sio.c m330_tmrb.c m330_wdt.c
  group TMPM330
    App/src/: vector.c
