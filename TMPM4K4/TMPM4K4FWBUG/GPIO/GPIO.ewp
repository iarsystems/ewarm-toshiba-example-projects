# IAR project GPIO.ewp, settings and files
configuration Flash (ARM, debug)
  General.OGChipSelectEditMenu: TMPM4K4FWBUG Toshiba TMPM4K4FWBUG
  General.RTConfigPath2: $TOOLKIT_DIR$/inc/c/DLib_Config_Normal.h
  General.CoreVariant: 39
  General.FPU2: 0
  ICCARM.CCIncludePath2: ..\..\Libraries\CMSIS; $TOOLKIT_DIR$\inc\Toshiba
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  ILINK.IlinkOutputFile: GPIO.out
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration RAM (ARM, debug)
  as the first configuration, except:
  ILINK.IlinkIcfFile: TMPM4K4FWBUG_RAM.icf
  group (top)
    ./: main.c readme.txt
    ../../Libraries/CMSIS/startup/iar/: startup_TMPM4K4B.s
    ../../Libraries/CMSIS/: system_TMPM4KxB.c
