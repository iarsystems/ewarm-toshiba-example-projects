<?xml version="1.0" encoding="iso-8859-1"?>
<workspace>
  <project>
    <path>$WS_DIR$/Blinking_LEDs.ewp</path>
  </project>
  <batchBuild>
    <batchDefinition>
      <name>All</name>
      <member>
        <project>Blinking_LEDs</project>
        <configuration>Debug iFlash</configuration>
      </member>
      <member>
        <project>Blinking_LEDs</project>
        <configuration>Debug iRAM</configuration>
      </member>
    </batchDefinition>
  </batchBuild>
</workspace>
