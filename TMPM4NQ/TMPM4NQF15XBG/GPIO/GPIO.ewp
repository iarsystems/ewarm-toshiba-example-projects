# IAR project GPIO.ewp, settings and files
configuration Debug iRAM (ARM, debug)
  General.OGChipSelectEditMenu: TMPM4NQF15XBG Toshiba TMPM4NQF15XBG
  General.RTConfigPath2: $TOOLKIT_DIR$/inc/c/DLib_Config_Normal.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCDefines: TMPM4NQ
  ICCARM.CCIncludePath2: ..\..\Libraries
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: GPIO.hex
  ILINK.IlinkOutputFile: GPIO.out
  ILINK.IlinkIcfFile: TMPM4NQF15XBG_RAM.icf
  ILINK.IlinkProgramEntryLabel: Reset_Handler
configuration Debug iFlash (ARM, debug)
  as the first configuration, except:
  group (top)
    ./: main.c readme.txt
    ../../Libraries/startup/: startup_TMPM4NQ.s
    ../../Libraries/: system_TMPM4Nx.c
