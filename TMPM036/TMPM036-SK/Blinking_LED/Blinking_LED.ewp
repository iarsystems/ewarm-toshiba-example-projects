# IAR project Blinking_LED.ewp, settings and files
configuration Debug iFlash (ARM, debug)
  General.OGChipSelectEditMenu: TMPM036FWFG Toshiba TMPM036FWFG
  General.RTConfigPath2: $TOOLKIT_DIR$/inc/c/DLib_Config_Normal.h
  General.CoreVariant: 34
  General.FPU2: 0
  ICCARM.CCIncludePath2: M036_CMSIS_header_V2.0.2.1\Libraries\TX00_CMSIS
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: Blinking_LED.hex
  ILINK.IlinkOutputFile: Blinking_LED.out
  ILINK.IlinkIcfFile: TMPM036FWFG_Flash.icf
  ILINK.IlinkProgramEntryLabel: Reset_Handler
  group (top)
    ./: main.c readme.txt
    M036_CMSIS_header_V2.0.2.1/Libraries/TX00_CMSIS/startup/iar/: startup_TMPM036.s
    M036_CMSIS_header_V2.0.2.1/Libraries/TX00_CMSIS/: system_TMPM036.c
