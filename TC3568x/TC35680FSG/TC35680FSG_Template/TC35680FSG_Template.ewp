# IAR project TC35680FSG_Template.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: TC35680FSG Toshiba TC35680FSG
  General.RTConfigPath2: $TOOLKIT_DIR$/inc/c/DLib_Config_Normal.h
  General.CoreVariant: 34
  General.FPU2: 0
  ICCARM.CCIncludePath2: src
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: TC35680FSG_Template.srec
  ILINK.IlinkOutputFile: test.out
  ILINK.IlinkProgramEntryLabel: C2_Task
  group (top)
    ./: c2_task.c
  group inc
    src/: host_api.h system_TC35680.h TC35680.h
  group supl_src
    src/: host_api.c host_api_defs.h regdef.h startup_TC35680.s system_TC35680.c tcu_defs.h
  group supl_src/config
    src/config/: RTE_Device.h
