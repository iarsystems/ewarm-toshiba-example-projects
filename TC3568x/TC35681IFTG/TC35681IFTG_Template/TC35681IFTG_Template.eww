<?xml version="1.0" encoding="UTF-8"?>
<workspace>
    <project>
        <path>$WS_DIR$/TC35681IFTG_Template.ewp</path>
    </project>
    <batchBuild/>
</workspace>
