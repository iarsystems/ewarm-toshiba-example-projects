# IAR project can_loopback.ewp, settings and files
configuration Debug_RAM (ARM, debug)
  General.OGChipSelectEditMenu: TMPM364F10FG Toshiba TMPM364F10FG
  General.RTConfigPath2: $TOOLKIT_DIR$/inc/c/DLib_Config_Normal.h
  General.CoreVariant: 38
  General.FPU2: 0
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: can_loopback.srec
  ILINK.IlinkOutputFile: $PROJ_FNAME$.out
  ILINK.IlinkIcfFile: config/TMPM364F10_RAM.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Debug_Flash (ARM, debug)
  as the first configuration, except:
  ILINK.IlinkIcfFile: config/TMPM364F10_Flash.icf
  group (top)
    ./: can.c main.c vectors.s
