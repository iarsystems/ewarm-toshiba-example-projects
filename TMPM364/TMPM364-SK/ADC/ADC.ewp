# IAR project ADC.ewp, settings and files
configuration Debug iRAM (ARM, debug)
  General.OGChipSelectEditMenu: TMPM364F10FG Toshiba TMPM364F10FG
  General.RTConfigPath2: $TOOLKIT_DIR$/inc/c/DLib_Config_Normal.h
  General.CoreVariant: 38
  General.FPU2: 0
  ICCARM.CCDefines: IAR_TMPM364_SK
  ICCARM.CCIncludePath2: ; board\; modules\
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: Blinking_LEDs.hex
  ILINK.IlinkOutputFile: Blinking_LEDs.out
  ILINK.IlinkIcfFile: config/TMPM364_RAM.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Debug iFlash (ARM, debug)
  as the first configuration, except:
  ILINK.IlinkIcfFile: config/TMPM364_Flash.icf
  group (top)
    ./: main.c readme.txt vectors.s
  group modules
    modules/: drv_cg.c drv_hd44780.c drv_hd44780_cnfg.h drv_hd44780_l.c
