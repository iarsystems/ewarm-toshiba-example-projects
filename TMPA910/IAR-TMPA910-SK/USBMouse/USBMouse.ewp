# IAR project USBMouse.ewp, settings and files
configuration iRam Debug (ARM, debug)
  General.OGChipSelectEditMenu: TMPA910CR Toshiba TMPA910CR
  General.RTConfigPath2: $TOOLKIT_DIR$/inc/c/DLib_Config_Normal.h
  General.CoreVariant: 12
  General.FPU2: 0
  ICCARM.CCIncludePath2: app/; board/; modules/
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  ILINK.IlinkOutputFile: USBMouse.out
  ILINK.IlinkIcfFile: config/iRam.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration SDRAM Debug (ARM, debug)
  as the first configuration, except:
  ILINK.IlinkIcfFile: config/SDRAM.icf
configuration NOR Flash Debug (ARM, debug)
  as the first configuration, except:
  ICCARM.CCDefines: SDRAM_INIT; NOR_INIT
  ILINK.IlinkIcfFile: config/NOR_Flash.icf
  group (top)
    app/: main.c
    ./: readme.txt
  group Modules
    app/: buttons.c
  group Startup
    board/: cstartup.s TMPA910_low_init.c
  group Startup/MMU
    board/: arm926ej_cp15_drv.c ttbl.c
  group USB/Class
    app/: hid_mouse.c usb_dev_desc.c usb_hooks.c
  group USB/Config
    app/: usb_cnfg.h
  group USB/Core
    modules/: usb_buffer.c usb_t9.c
  group USB/HW
    modules/: usb_hw.c
