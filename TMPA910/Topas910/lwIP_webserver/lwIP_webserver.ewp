# IAR project lwIP_webserver.ewp, settings and files
configuration SDRAM Debug (ARM, debug)
  General.OGChipSelectEditMenu: TMPA910CR Toshiba TMPA910CR
  General.RTConfigPath2: $TOOLKIT_DIR$/inc/c/DLib_Config_Normal.h
  General.CoreVariant: 12
  General.FPU2: 0
  ICCARM.CCIncludePath2: board; lwip-1.3.1\src; lwip-1.3.1\src\include; lwip-1.3.1\src\include\ipv4; lwip-1.3.1\src\arch\include
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  ILINK.IlinkOutputFile: GettingStarted.out
  ILINK.IlinkIcfFile: config/SDRAM.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration NOR Flash Debug (ARM, debug)
  as the first configuration, except:
  ICCARM.CCDefines: SDRAM_INIT; NOR_INIT
  ILINK.IlinkIcfFile: config/NOR_Flash.icf
  group (top)
    ./: httpd.c main.c readme.txt
    lwip-1.3.1/src/include/: lwipopts.h
  group lwIP/api
    lwip-1.3.1/src/api/: api_lib.c api_msg.c err.c netbuf.c netdb.c netifapi.c sockets.c tcpip.c
  group lwIP/arch
    lwip-1.3.1/src/arch/: sys_arch.c
  group lwIP/arch/netif
    lwip-1.3.1/src/arch/netif/: dm9000_iar_tmpa910.c iar_tmpa910_if.c
  group lwIP/core
    lwip-1.3.1/src/core/: dhcp.c dns.c init.c mem.c memp.c netif.c pbuf.c raw.c stats.c sys.c tcp.c tcp_in.c tcp_out.c udp.c
  group lwIP/core/ipv4
    lwip-1.3.1/src/core/ipv4/: autoip.c icmp.c igmp.c inet.c inet_chksum.c ip.c ip_addr.c ip_frag.c
  group lwIP/core/ipv6
    lwip-1.3.1/src/core/ipv6/: icmp6.c inet6.c ip6.c ip6_addr.c
  group lwIP/core/snmp
    lwip-1.3.1/src/core/snmp/: asn1_dec.c asn1_enc.c mib2.c mib_structs.c msg_in.c msg_out.c
  group lwIP/netif
    lwip-1.3.1/src/netif/: etharp.c ethernetif.c loopif.c slipif.c
  group Startup
    board/: cstartup.s TMPA910_low_init.c
  group Startup/MMU
    board/: arm926ej_cp15_drv.c ttbl.c
