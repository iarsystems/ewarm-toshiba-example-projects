# IAR project Blinking_LED.ewp, settings and files
configuration Debug iRAM (ARM, debug)
  General.OGChipSelectEditMenu: TMPM46BF10FG Toshiba TMPM46BF10FG
  General.RTConfigPath2: $TOOLKIT_DIR$/inc/c/DLib_Config_Normal.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCIncludePath2: CMSIS\Libraries\TX04_CMSIS
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: Blinking_LED.hex
  ILINK.IlinkOutputFile: Blinking_LED.out
  ILINK.IlinkIcfFile: TMPM46BF10FG_RAM.icf
  ILINK.IlinkProgramEntryLabel: Reset_Handler
configuration Debug iFlash (ARM, debug)
  as the first configuration, except:
  ILINK.IlinkIcfFile: TMPM46BF10FG_Flash.icf
  group (top)
    ./: main.c readme.txt
    CMSIS/Libraries/TX04_CMSIS/startup/iar/: startup_TMPM46B.s
    CMSIS/Libraries/TX04_CMSIS/: system_TMPM46B.c
