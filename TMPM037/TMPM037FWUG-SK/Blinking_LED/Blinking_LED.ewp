# IAR project Blinking_LED.ewp, settings and files
configuration Debug iFlash (ARM, debug)
  General.OGChipSelectEditMenu: TMPM037FWUG Toshiba TMPM037FWUG
  General.RTConfigPath2: $TOOLKIT_DIR$/inc/c/DLib_Config_Normal.h
  General.CoreVariant: 34
  General.FPU2: 0
  ICCARM.CCIncludePath2: M037_CMSIS_header_V2.0.2.3\Libraries\TX00_CMSIS
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: Blinking_LED.hex
  ILINK.IlinkOutputFile: Blinking_LED.out
  ILINK.IlinkProgramEntryLabel: Reset_Handler
  group (top)
    ./: main.c readme.txt
    M037_CMSIS_header_V2.0.2.3/Libraries/TX00_CMSIS/startup/iar/: startup_TMPM037.s
    M037_CMSIS_header_V2.0.2.3/Libraries/TX00_CMSIS/: system_TMPM037.c
