# IAR project Blinking_LED.ewp, settings and files
configuration Debug iRAM (ARM, debug)
  General.OGChipSelectEditMenu: TMPM462F10FG Toshiba TMPM462F10FG
  General.RTConfigPath2: $TOOLKIT_DIR$/inc/c/DLib_Config_Normal.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: Blinking_LED.hex
  ILINK.IlinkOutputFile: Blinking_LED.out
  ILINK.IlinkIcfFile: TMPM462_RAM.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Debug iFlash (ARM, debug)
  as the first configuration, except:
  ILINK.IlinkIcfFile: TMPM462_Flash.icf
  group (top)
    ./: main.c readme.txt
