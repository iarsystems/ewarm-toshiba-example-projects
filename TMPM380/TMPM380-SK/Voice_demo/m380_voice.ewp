# IAR project m380_voice.ewp, settings and files
configuration sFlash (ARM, debug)
  General.OGChipSelectEditMenu: TMPM380FYFG Toshiba TMPM380FYFG
  General.RTConfigPath2: $TOOLKIT_DIR$/INC/c/DLib_Config_Normal.h
  ICCARM.CCDefines: SAMPLE_8K
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: m380_voice.srec
  ILINK.IlinkOutputFile: m380_voice.out
  ILINK.IlinkIcfFile: TMPM380_Flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group app
    app/: int_set.c led_ctrl.c main.c mcu_set.c mode_ctrl.c spiflash.c system_it.c vector.c voice_ctrl.c
  group data
    data/: voice_data.c
  group mcu
    mcu/: m380_cg.c m380_int.c m380_mpt.c m380_port.c m380_spi.c m380_tmrb.c m380_wdt.c tmpm380_sys.c
