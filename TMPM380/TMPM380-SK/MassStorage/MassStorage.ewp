# IAR project MassStorage.ewp, settings and files
configuration FLASH (ARM, debug)
  General.OGChipSelectEditMenu: TMPM380FYFG Toshiba TMPM380FYFG
  General.RTConfigPath2: $TOOLKIT_DIR$/INC/c/DLib_Config_Normal.h
  ICCARM.CCIncludePath2: mcu\; app\; sd\; 
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: MassStorage.srec
  ILINK.IlinkOutputFile: MassStorage.out
  ILINK.IlinkIcfFile: TMPM380_Flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration RAM (ARM, debug)
  as the first configuration, except:
  ILINK.IlinkIcfFile: TMPM380_RAM.icf
  group app
    app/: main.c mcu_set.c system_it.c uart.c vector.c
  group mcu
    mcu/: m380_cg.c m380_int.c m380_mpt.c m380_port.c m380_sio.c m380_spi.c m380_spi1.c m380_tmrb.c m380_wdt.c tmpm380_sys.c
  group sd
    sd/: sd_spi.c sd_spi_mode.c
