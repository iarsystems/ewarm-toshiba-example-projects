# IAR project Blinking_LED.ewp, settings and files
configuration Debug iRAM (ARM, debug)
  General.OGChipSelectEditMenu: TMPM381FWFG Toshiba TMPM381FWFG
  General.RTConfigPath2: $TOOLKIT_DIR$/inc/c/DLib_Config_Normal.h
  General.CoreVariant: 38
  General.FPU2: 0
  ICCARM.CCIncludePath2: ..\..\TMPM380CMSIS
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: Blinking_LED.hex
  ILINK.IlinkOutputFile: Blinking_LED.out
  ILINK.IlinkIcfFile: TMPM381FWFG_RAM.icf
  ILINK.IlinkProgramEntryLabel: Reset_Handler
configuration Debug iFlash (ARM, debug)
  as the first configuration, except:
  group (top)
    ./: main.c readme.txt
    ../../TMPM380CMSIS/startup/iar/: startup_TMPM381.s
    ../../TMPM380CMSIS/: system_TMPM381.c
