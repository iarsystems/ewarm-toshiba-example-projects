# IAR project Blinking_LED.ewp, settings and files
configuration Debug iRAM (ARM, debug)
  General.OGChipSelectEditMenu: TMPM36BFYFG Toshiba TMPM36BFYFG
  General.RTConfigPath2: $TOOLKIT_DIR$/inc/c/DLib_Config_Normal.h
  General.CoreVariant: 38
  General.FPU2: 0
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: Blinking_LED.hex
  ILINK.IlinkOutputFile: $PROJ_FNAME$.out
  ILINK.IlinkIcfFile: TMPM36B_RAM.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Debug iFlash (ARM, debug)
  as the first configuration, except:
  ILINK.IlinkIcfFile: TMPM36B_Flash.icf
  group (top)
    ./: main.c readme.txt
