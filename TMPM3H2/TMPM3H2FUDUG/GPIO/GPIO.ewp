# IAR project GPIO.ewp, settings and files
configuration Debug iRAM (ARM, debug)
  General.OGChipSelectEditMenu: TMPM3H2FUDUG Toshiba TMPM3H2FUDUG
  General.RTConfigPath2: $TOOLKIT_DIR$/inc/c/DLib_Config_Normal.h
  General.CoreVariant: 38
  General.FPU2: 0
  ICCARM.CCDefines: TMPM3H2
  ICCARM.CCIncludePath2: ..\..\Libraries\TX03_CMSIS; $TOOLKIT_DIR$\inc\Toshiba
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: GPIO.hex
  ILINK.IlinkOutputFile: GPIO.out
  ILINK.IlinkIcfFile: TMPM3H2FUDUG_RAM.icf
  ILINK.IlinkProgramEntryLabel: Reset_Handler
configuration Debug iFlash (ARM, debug)
  as the first configuration, except:
  ILINK.IlinkIcfFile: TMPM3H2FUDUG_Flash.icf
  group (top)
    ./: main.c readme.txt
    ../../Libraries/TX03_CMSIS/startup/iar/: startup_TMPM3H2.s
    ../../Libraries/TX03_CMSIS/: system_TMPM3Hx.c
