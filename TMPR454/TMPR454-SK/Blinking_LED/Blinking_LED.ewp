# IAR project Blinking_LED.ewp, settings and files
configuration Debug iFlash (ARM, debug)
  General.OGChipSelectEditMenu: TMPR454F10TFG Toshiba TMPR454F10TFG
  General.RTConfigPath2: $TOOLKIT_DIR$/inc/c/DLib_Config_Normal.h
  General.CoreVariant: 42
  General.FPU2: 3
  ICCARM.CCDefines: FLASH_MODE
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: Blinking_LED.srec
  ILINK.IlinkOutputFile: Blinking_LED.out
  ILINK.IlinkIcfFile: TMPR454_Flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group (top)
    ./: cstartup.s main.c
