# IAR project GPIO.ewp, settings and files
configuration Debug iRAM (ARM, debug)
  General.OGChipSelectEditMenu: TMPM3U0FSDMG Toshiba TMPM3U0FSDMG
  General.RTConfigPath2: $TOOLKIT_DIR$/inc/c/DLib_Config_Normal.h
  General.CoreVariant: 38
  General.FPU2: 0
  ICCARM.CCDefines: TMPM3U0
  ICCARM.CCIncludePath2: ..\..\Libraries\CMSIS; $TOOLKIT_DIR$\inc\Toshiba
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: GPIO.hex
  ILINK.IlinkOutputFile: GPIO.out
  ILINK.IlinkIcfFile: TMPM3U0FSDMG_RAM.icf
  ILINK.IlinkProgramEntryLabel: Reset_Handler
configuration Debug iFlash (ARM, debug)
  as the first configuration, except:
  ILINK.IlinkIcfFile: TMPM3U0FSDMG_Flash.icf
  group (top)
    ./: main.c readme.txt
    ../../Libraries/CMSIS/startup/iar/: startup_TMPM3U0.s
    ../../Libraries/CMSIS/: system_TMPM3U0.c
