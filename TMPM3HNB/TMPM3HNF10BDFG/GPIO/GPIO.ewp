# IAR project GPIO.ewp, settings and files
configuration Flash (ARM, debug)
  General.OGChipSelectEditMenu: TMPM3HNF10BDFG Toshiba TMPM3HNF10BDFG
  General.RTConfigPath2: $TOOLKIT_DIR$/inc/c/DLib_Config_Normal.h
  General.CoreVariant: 38
  General.FPU2: 0
  ICCARM.CCIncludePath2: $PROJ_DIR$; $TOOLKIT_DIR$\inc\Toshiba; ..\..\Libraries
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: GPIO.srec
  ILINK.IlinkOutputFile: GPIO.out
  ILINK.IlinkProgramEntryLabel: Reset_Handler
configuration RAM (ARM, debug)
  as the first configuration, except:
  ILINK.IlinkIcfFile: TMPM3HNF10BDFG_RAM.icf
  group (top)
    ./: main.c readme.txt
    ../../Libraries/startup/: startup_TMPM3HNB.s
    ../../Libraries/: system_TMPM3HyB.c
