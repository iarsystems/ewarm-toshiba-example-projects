# IAR project GPIO.ewp, settings and files
configuration Debug iRAM (ARM, debug)
  General.OGChipSelectEditMenu: TMPM3HMFZAFG Toshiba TMPM3HMFZAFG
  General.RTConfigPath2: $TOOLKIT_DIR$/inc/c/DLib_Config_Normal.h
  General.CoreVariant: 38
  General.FPU2: 0
  ICCARM.CCDefines: TMPM3HMA
  ICCARM.CCIncludePath2: ..\..\Libraries; $TOOLKIT_DIR$\inc\Toshiba
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: GPIO.hex
  ILINK.IlinkOutputFile: GPIO.out
  ILINK.IlinkIcfFile: TMPM3HMFZAFG_RAM.icf
  ILINK.IlinkProgramEntryLabel: Reset_Handler
configuration Debug iFlash (ARM, debug)
  as the first configuration, except:
  group (top)
    ./: main.c readme.txt
    ../../Libraries/startup/: startup_TMPM3HMA.s
    ../../Libraries/: system_TMPM3HxA.c
