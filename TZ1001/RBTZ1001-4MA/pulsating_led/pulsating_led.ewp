# IAR project pulsating_led.ewp, settings and files
configuration Flash_Debug (ARM, debug)
  General.OGChipSelectEditMenu: TZ1001MBG Toshiba TZ1001MBG
  General.RTConfigPath2: $TOOLKIT_DIR$/inc/c/DLib_Config_Normal.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCDefines: TZ10XX_BOOT_FLASH
  ICCARM.CCIncludePath2: RTE\Device\TZ1001MBG\
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  AARM.ADefines: TZ10XX_BOOT_FLASH
  OBJCOPY.OOCOutputFile: sample.srec
  ILINK.IlinkOutputFile: $PROJ_FNAME$.out
  ILINK.IlinkIcfFile: TZ1001_Flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration RAM_Debug (ARM, debug)
  as the first configuration, except:
  ICCARM.CCDefines: TZ10XX_BOOT_RAM
  AARM.ADefines: TZ10XX_BOOT_RAM
  ILINK.IlinkIcfFile: TZ1001_RAM.icf
  group (top)
    ./: low_level_init.c pulsating_led.c
  group Device
    RTE/Device/TZ1001MBG/: bootloader_TZ10xx.s startup_TZ10xx.s system_TZ10xx.c system_TZ10xx.h
