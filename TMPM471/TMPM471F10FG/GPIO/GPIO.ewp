# IAR project GPIO.ewp, settings and files
configuration RAM (ARM, debug)
  General.OGChipSelectEditMenu: TMPM471F10FG Toshiba TMPM471F10FG
  General.RTConfigPath2: $TOOLKIT_DIR$/inc/c/DLib_Config_Normal.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCIncludePath2: $TOOLKIT_DIR$\inc\Toshiba; ..\..\Libraries
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  ILINK.IlinkOutputFile: GPIO.out
  ILINK.IlinkIcfFile: TMPM471F10FG_RAM.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Flash (ARM, debug)
  as the first configuration, except:
  group (top)
    ./: main.c
    ../../Libraries/startup/iar/: startup_TMPM471F10.s
    ../../Libraries/: system_TMPM471F10.c
