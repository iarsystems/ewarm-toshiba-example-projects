# IAR project A90xSampleUSBH.ewp, settings and files
configuration SDRAM Debug (ARM, debug)
  General.OGChipSelectEditMenu: TMPA900CM Toshiba TMPA900CM
  General.RTConfigPath2: $TOOLKIT_DIR$/inc/c/DLib_Config_Normal.h
  General.CoreVariant: 12
  General.FPU2: 0
  ICCARM.CCDefines: MMCU_CORE=1
  ICCARM.CCDiagSuppress: Pe301, Pe177, Pe550, Pe236
  ICCARM.CCIncludePath2: ..\source; ..\source\Application\USBH; ..\source\Application\DebugIP; ..\source\uart; ..\source\timer; ..\source\usbh\src; ..\source\usbh\wrapper; ..\source\usbh\include; ..\source\usbh\src\util; ..\source\usbh\src\usbd; ..\source\usbh\src\class; ..\source\usbh\src\class\massstorage; ..\source\usbh\src\hcd\ohci
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  AARM.ADefines: CLOCK_NO_INIT; MPMC0_NO_INIT; DMC_MPMC0_NO_INIT; REMAP
  ILINK.IlinkOutputFile: USBMouse.out
  ILINK.IlinkIcfFile: ../config/SDRAM.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration NOR Flash Debug (ARM, debug)
  as the first configuration, except:
  ILINK.IlinkIcfFile: ../config/NOR_Flash.icf
  group (top)
    ../source/Application/DebugIP/: DebugIP.a
    ../source/: main.c mmu_tbl.c
    ./: readme.txt
  group Application/DebugIP
    ../source/Application/DebugIP/: Debug_hw.c
  group Application/USBH
    ../source/Application/USBH/: sample_usbh.c
  group DMAC
    ../source/DMAC/: dmac.c
  group Startup
    ../source/: fiq.s irq.s sub_main.c TMPA900.s
  group Timer
    ../source/Timer/: timer.c
  group UART
    ../source/UART/: uart.c
  group USBH/class
    ../source/USBH/src/class/: usb_classdrv.c usb_classdrvblock.c usb_classdrvmem.c
  group USBH/class/massstorage
    ../source/USBH/src/class/massstorage/: usb_msc_core.c usb_mscapi.c usb_mscbbb.c usb_msccbi.c usb_mscmem.c usb_scsi.c
  group USBH/hcd/ohci
    ../source/USBH/src/hcd/ohci/: usb_ohciinit.c usb_ohciintr.c usb_ohcilib.c usb_ohcimem.c usb_ohciroothub.c usb_ohcixfer.c
  group USBH/usbd
    ../source/USBH/src/usbd/: usb_uhub.c usb_usbd.c usb_usbd_mem.c usb_usbd_subr.c usb_usbd_util.c
  group USBH/util
    ../source/USBH/src/util/: usb_ctxswt.c usb_CTXSWT_blIntrCtx.s usb_CTXSWT_vChgIntrCtx.s usb_CTXSWT_vSlpIntrCtx.s usb_dbg.c usb_intr.c usb_intr_hw.c usb_queue.c usb_tmr.c usb_trace.c
  group USBH/wrapper
    ../source/USBH/wrapper/: msctolsapi2.c
