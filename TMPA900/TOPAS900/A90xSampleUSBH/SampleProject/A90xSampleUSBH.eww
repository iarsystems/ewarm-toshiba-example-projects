<?xml version="1.0" encoding="iso-8859-1"?>
<workspace>
  <project>
    <path>$WS_DIR$/A90xSampleUSBH.ewp</path>
  </project>
  <batchBuild>
    <batchDefinition>
      <name>All</name>
      <member>
        <project>A90xSampleUSBH</project>
        <configuration>NOR Flash Debug</configuration>
      </member>
      <member>
        <project>A90xSampleUSBH</project>
        <configuration>SDRAM Debug</configuration>
      </member>
    </batchDefinition>
  </batchBuild>
</workspace>
