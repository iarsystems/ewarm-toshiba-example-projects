<?xml version="1.0" encoding="iso-8859-1"?>
<workspace>
  <project>
    <path>$WS_DIR$/lwIP_webserver.ewp</path>
  </project>
  <batchBuild>
    <batchDefinition>
      <name>All</name>
      <member>
        <project>lwIP_webserver</project>
        <configuration>NOR Flash Debug</configuration>
      </member>
      <member>
        <project>lwIP_webserver</project>
        <configuration>SDRAM Debug</configuration>
      </member>
    </batchDefinition>
  </batchBuild>
</workspace>
