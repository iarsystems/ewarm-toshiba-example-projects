# IAR project RotaryEncoder.ewp, settings and files
configuration Debug iRAM (ARM, debug)
  General.OGChipSelectEditMenu: TMPM440FEXBG Toshiba TMPM440FEXBG
  General.RTConfigPath2: $TOOLKIT_DIR$/inc/c/DLib_Config_Normal.h
  General.CoreVariant: 39
  General.FPU2: 0
  ICCARM.CCIncludePath2: board; modules; $PROJ_DIR$
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  AARM.AUserIncludes: modules
  OBJCOPY.OOCOutputFile: RotaryEncoder.hex
  ILINK.IlinkOutputFile: RotaryEncoder.out
  ILINK.IlinkIcfFile: TMPM440_RAM.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Debug iFlash (ARM, debug)
  as the first configuration, except:
  General.FPU2: 4
  ILINK.IlinkIcfFile: TMPM440_Flash.icf
configuration Debug iRAM_BE8 (ARM, debug)
  as the first configuration, except:
  General.FPU2: 4
configuration Debug iFlash_BE8 (ARM, debug)
  as the first configuration, except:
  General.FPU2: 4
  ILINK.IlinkIcfFile: TMPM440_Flash.icf
  group (top)
    ./: main.c readme.txt vector_table.c
  group board
    board/: board.c
  group modules
    modules/: drv_cg.c drv_gpio.c drv_nvic.c
