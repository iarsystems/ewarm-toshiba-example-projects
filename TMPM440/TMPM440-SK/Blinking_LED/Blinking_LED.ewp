# IAR project Blinking_LED.ewp, settings and files
configuration Debug iRAM (ARM, debug)
  General.OGChipSelectEditMenu: TMPM440FEXBG Toshiba TMPM440FEXBG
  General.RTConfigPath2: $TOOLKIT_DIR$/inc/c/DLib_Config_Normal.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: Blinking_LED.hex
  ILINK.IlinkOutputFile: Blinking_LED.out
  ILINK.IlinkIcfFile: TMPM440_RAM.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Debug iFlash (ARM, debug)
  as the first configuration, except:
  General.FPU2: 0
  ILINK.IlinkIcfFile: TMPM440_Flash.icf
configuration Debug iRAM_BE8 (ARM, debug)
  as the first configuration, except:
  General.FPU2: 0
configuration Debug iFlash_BE8 (ARM, debug)
  as the first configuration, except:
  General.FPU2: 0
  ILINK.IlinkIcfFile: TMPM440_Flash.icf
  group (top)
    ./: main.c readme.txt
