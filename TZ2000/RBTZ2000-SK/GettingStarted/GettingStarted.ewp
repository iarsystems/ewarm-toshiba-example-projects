# IAR project GettingStarted.ewp, settings and files
configuration SRAM Debug (ARM, debug)
  General.OGChipSelectEditMenu: TZ2002XBG Toshiba TZ2002XBG
  General.RTConfigPath2: $TOOLKIT_DIR$/inc/c/DLib_Config_Normal.h
  General.CoreVariant: 54
  General.FPU2: 0
  ICCARM.CCIncludePath2: board
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: GettingStarted.srec
  ILINK.IlinkOutputFile: GettingStarted.out
  ILINK.IlinkIcfFile: config/RBTZ2000SK_SRAM.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration DDR Debug (ARM)
  as the first configuration, except:
  ICCARM.CCIncludePath2: board\
  group (top)
    ./: armv7a_cp15_drv.c main.c readme.txt
  group board
    board/: board.h
