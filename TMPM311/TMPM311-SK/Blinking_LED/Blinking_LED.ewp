# IAR project Blinking_LED.ewp, settings and files
configuration Debug iRAM (ARM, debug)
  General.OGChipSelectEditMenu: TMPM311CHDUG Toshiba TMPM311CHDUG
  General.RTConfigPath2: $TOOLKIT_DIR$/inc/c/DLib_Config_Normal.h
  General.CoreVariant: 38
  General.FPU2: 0
  ICCARM.CCIncludePath2: ..\..\CMSIS\Device\Toshiba\TMPM310\Include
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: Blinking_LED.hex
  ILINK.IlinkOutputFile: Blinking_LED.out
  ILINK.IlinkProgramEntryLabel: Reset_Handler
  group (top)
    ./: main.c readme.txt
  group CMSIS
    ../../CMSIS/Device/Toshiba/TMPM310/Source/iar/: startup_TMPM311.s
    ../../CMSIS/Device/Toshiba/TMPM310/Source/: system_TMPM311.c
