# IAR project MassStorage.ewp, settings and files
configuration Debug iRAM (ARM, debug)
  General.OGChipSelectEditMenu: TMPM369FDFG Toshiba TMPM369FDFG
  General.RTConfigPath2: $TOOLKIT_DIR$/INC/c/DLib_Config_Normal.h
  ICCARM.CCDefines: IAR_TMPM369_SK
  ICCARM.CCIncludePath2: ; app; modules; board
  ICCARM.CCOptLevel: 2
  ICCARM.CCOptStrategy: 2
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: Blinking_LEDs.hex
  ILINK.IlinkOutputFile: $PROJ_FNAME$.out
  ILINK.IlinkIcfFile: config/TMPM369_RAM.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Debug iFlash (ARM, debug)
  as the first configuration, except:
  ICCARM.CCOptLevel: 0
  ILINK.IlinkIcfFile: config/TMPM369_Flash.icf
  group (top)
    ./: cstartup_M.s readme.txt
    app/: main.c
  group Luns
    app/: lun.c
  group Luns/SD/MMC
    app/: sd_dsk_desc.c sd_spi_mode.c
  group modules
    modules/: drv_cg.c drv_hd44780.c drv_hd44780_l.c drv_nvic.c
    app/: sd_ll_spi.c
  group USB/Class
    app/: scsi.c scsi_ll.c usb_dev_desc.c usb_hooks.c
  group USB/Config
    app/: usb_cnfg.h
  group USB/Core
    modules/: usb_buffer.c usb_t9.c
  group USB/HW
    modules/: usb_hw.c
