<?xml version="1.0" encoding="iso-8859-1"?>
<workspace>
  <project>
    <path>$WS_DIR$/LCD.ewp</path>
  </project>
  <batchBuild>
    <batchDefinition>
      <name>All</name>
      <member>
        <project>LCD</project>
        <configuration>Debug iFlash</configuration>
      </member>
      <member>
        <project>LCD</project>
        <configuration>Debug iRAM</configuration>
      </member>
    </batchDefinition>
  </batchBuild>
</workspace>
