<?xml version="1.0" encoding="iso-8859-1"?>
<workspace>
  <project>
    <path>$WS_DIR$/can_loopback.ewp</path>
  </project>
  <batchBuild>
    <batchDefinition>
      <name>All</name>
      <member>
        <project>can_loopback</project>
        <configuration>Debug_Flash</configuration>
      </member>
      <member>
        <project>can_loopback</project>
        <configuration>Debug_RAM</configuration>
      </member>
    </batchDefinition>
  </batchBuild>
</workspace>
