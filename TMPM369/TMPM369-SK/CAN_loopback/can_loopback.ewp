# IAR project can_loopback.ewp, settings and files
configuration Debug_RAM (ARM, debug)
  General.OGChipSelectEditMenu: TMPM369FDFG Toshiba TMPM369FDFG
  General.RTConfigPath2: $TOOLKIT_DIR$/INC/c/DLib_Config_Normal.h
  ICCARM.CCDefines: IAR_TMPM369_SK
  ICCARM.CCIncludePath2: $PROJ_DIR$; modules; board
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: can_loopback.srec
  ILINK.IlinkOutputFile: $PROJ_FNAME$.out
  ILINK.IlinkIcfFile: TMPM369_RAM.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Debug_Flash (ARM, debug)
  as the first configuration, except:
  General.OGChipSelectEditMenu: TMPM364F10FG Toshiba TMPM364F10FG
  ILINK.IlinkIcfFile: TMPM369_Flash.icf
  group (top)
    ./: can.c cstartup_M.s main.c
  group modules
    modules/: drv_cg.c drv_nvic.c
