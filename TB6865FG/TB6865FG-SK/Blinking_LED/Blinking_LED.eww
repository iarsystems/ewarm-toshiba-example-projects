<?xml version="1.0" encoding="iso-8859-1"?>
<workspace>
  <project>
    <path>$WS_DIR$/Blinking_LED.ewp</path>
  </project>
  <batchBuild>
    <batchDefinition>
      <name>All</name>
      <member>
        <project>Blinking_LED</project>
        <configuration>Debug iFlash</configuration>
      </member>
      <member>
        <project>Blinking_LED</project>
        <configuration>Debug iFlash BE8</configuration>
      </member>
      <member>
        <project>Blinking_LED</project>
        <configuration>Debug iRAM</configuration>
      </member>
      <member>
        <project>Blinking_LED</project>
        <configuration>Debug iRAM BE8</configuration>
      </member>
    </batchDefinition>
  </batchBuild>
</workspace>
