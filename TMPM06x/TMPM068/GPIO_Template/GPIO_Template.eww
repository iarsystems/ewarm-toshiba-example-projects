<?xml version="1.0" encoding="iso-8859-1"?>
<workspace>
  <project>
    <path>$WS_DIR$/GPIO_Template.ewp</path>
  </project>
  <batchBuild>
    <batchDefinition>
      <name>All</name>
      <member>
        <project>GPIO_Template</project>
        <configuration>Debug iFlash</configuration>
      </member>
    </batchDefinition>
  </batchBuild>
</workspace>
