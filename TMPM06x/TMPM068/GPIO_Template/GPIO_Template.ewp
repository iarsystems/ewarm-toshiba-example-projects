# IAR project GPIO_Template.ewp, settings and files
configuration Debug iFlash (ARM, debug)
  General.OGChipSelectEditMenu: TMPM068FWXBG Toshiba TMPM068FWXBG
  General.RTConfigPath2: $TOOLKIT_DIR$/inc/c/DLib_Config_Normal.h
  General.CoreVariant: 34
  General.FPU2: 0
  ICCARM.CCIncludePath2: M068_CMSIS\Libraries\TX00_CMSIS; $TOOLKIT_DIR$\inc\Toshiba
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: GPIO.hex
  ILINK.IlinkOutputFile: GPIO.out
  ILINK.IlinkProgramEntryLabel: Reset_Handler
  group (top)
    ./: main.c readme.txt
    M068_CMSIS/Libraries/TX00_CMSIS/startup/iar/: startup_TMPM068.s
    M068_CMSIS/Libraries/TX00_CMSIS/: system_TMPM068.c
