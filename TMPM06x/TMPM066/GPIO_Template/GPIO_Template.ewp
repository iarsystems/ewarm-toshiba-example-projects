# IAR project GPIO_Template.ewp, settings and files
configuration Debug iFlash (ARM, debug)
  General.OGChipSelectEditMenu: TMPM066FWUG Toshiba TMPM066FWUG
  General.RTConfigPath2: $TOOLKIT_DIR$/inc/c/DLib_Config_Normal.h
  General.CoreVariant: 34
  General.FPU2: 0
  ICCARM.CCIncludePath2: M066_CMSIS\Libraries\TX00_CMSIS; $TOOLKIT_DIR$\inc\Toshiba
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: GPIO.hex
  ILINK.IlinkOutputFile: GPIO.out
  ILINK.IlinkProgramEntryLabel: Reset_Handler
  group (top)
    ./: main.c readme.txt
    M066_CMSIS/Libraries/TX00_CMSIS/startup/iar/: startup_TMPM066.s
    M066_CMSIS/Libraries/TX00_CMSIS/: system_TMPM066.c
